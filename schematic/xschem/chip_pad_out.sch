v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {chip_pad_out} 0 -60 0 0 0.8 0.8 {}
T {The pad pins carry labels instead of wires. The ties are the ones of rtl/lit_compac_top.sv.} 0 -30 0 0 0.4 0.4 {}
C {sky130_ef_io/sky130_ef_io__gpiov2_pad.sym} 700 -500 0 0 {name=x_pad}
C {lab_pin.sym} 820 -710 2 0 {name=l1 lab=in_h}
C {lab_pin.sym} 580 -710 0 0 {name=l2 lab=pad_a_noesd_h}
C {lab_pin.sym} 580 -690 0 0 {name=l3 lab=pad_a_esd_0_h}
C {lab_pin.sym} 580 -670 0 0 {name=l4 lab=pad_a_esd_1_h}
C {lab_pin.sym} 580 -650 0 0 {name=l5 lab=pad}
C {lab_pin.sym} 820 -690 2 0 {name=l6 lab=hi}
C {lab_pin.sym} 820 -670 2 0 {name=l7 lab=hi}
C {lab_pin.sym} 820 -650 2 0 {name=l8 lab=lo}
C {lab_pin.sym} 820 -630 2 0 {name=l9 lab=tie_hi}
C {lab_pin.sym} 820 -610 2 0 {name=l10 lab=in}
C {lab_pin.sym} 820 -590 2 0 {name=l11 lab=hi}
C {lab_pin.sym} 820 -570 2 0 {name=l12 lab=lo}
C {lab_pin.sym} 820 -550 2 0 {name=l13 lab=tie_hi}
C {lab_pin.sym} 820 -530 2 0 {name=l14 lab=tie_hi}
C {lab_pin.sym} 820 -510 2 0 {name=l15 lab=tie_lo}
C {lab_pin.sym} 820 -490 2 0 {name=l16 lab=lo}
C {lab_pin.sym} 820 -470 2 0 {name=l17 lab=tie_hi}
C {lab_pin.sym} 820 -450 2 0 {name=l18 lab=tie_lo}
C {lab_pin.sym} 820 -430 2 0 {name=l19 lab=lo}
C {lab_pin.sym} 620 -750 0 0 {name=l20 lab=lo}
C {lab_pin.sym} 820 -410 2 0 {name=l21 lab=lo}
C {lab_pin.sym} 820 -390 2 0 {name=l22 lab=lo}
C {lab_pin.sym} 820 -370 2 0 {name=l23 lab=lo}
C {lab_pin.sym} 820 -350 2 0 {name=l24 lab=hi}
C {lab_pin.sym} 820 -330 2 0 {name=l25 lab=tie_lo}
C {lab_pin.sym} 820 -310 2 0 {name=l26 lab=lo}
C {lab_pin.sym} 820 -290 2 0 {name=l27 lab=c2p}
C {lab_pin.sym} 640 -750 0 0 {name=l28 lab=AMUXBUS_A}
C {lab_pin.sym} 660 -750 0 0 {name=l29 lab=AMUXBUS_B}
C {lab_pin.sym} 620 -250 0 0 {name=l30 lab=IOVSS}
C {lab_pin.sym} 680 -750 0 0 {name=l31 lab=IOVDD}
C {lab_pin.sym} 700 -750 0 0 {name=l32 lab=IOVDD}
C {lab_pin.sym} 720 -750 2 0 {name=l33 lab=IOVDD}
C {lab_pin.sym} 740 -750 2 0 {name=l34 lab=VDD}
C {lab_pin.sym} 760 -750 2 0 {name=l35 lab=IOVDD}
C {lab_pin.sym} 780 -750 2 0 {name=l36 lab=VDD}
C {lab_pin.sym} 640 -250 0 0 {name=l37 lab=IOVSS}
C {lab_pin.sym} 660 -250 0 0 {name=l38 lab=VSS}
C {lab_pin.sym} 680 -250 0 0 {name=l39 lab=IOVSS}
C {sky130_stdcells/conb_1.sym} 200 -700 0 0 {name=x_tie VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__}
C {lab_pin.sym} 260 -720 2 0 {name=l40 lab=hi}
C {lab_pin.sym} 260 -680 2 0 {name=l41 lab=lo}
C {devices/iopin.sym} 100 -200 0 0 {name=p42 lab=VDD}
C {devices/iopin.sym} 100 -240 0 0 {name=p43 lab=VSS}
C {devices/iopin.sym} 100 -280 0 0 {name=p44 lab=IOVDD}
C {devices/iopin.sym} 100 -320 0 0 {name=p45 lab=IOVSS}
C {devices/iopin.sym} 100 -360 0 0 {name=p46 lab=pad}
C {devices/ipin.sym} 100 -400 0 0 {name=p47 lab=c2p}
